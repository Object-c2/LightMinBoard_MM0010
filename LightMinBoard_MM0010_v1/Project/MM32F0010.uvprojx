# Keil uVision project MM32F0010.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MM32F0010A1T MindMotion
  pack: MindMotion.MM32F0010_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32F0010_转接板程序
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\CMSIS;..\Device\Include;..\Device\HAL_Lib\Inc;..\User\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ../User/src/: init.c io.c main.c uart.c irq.c uart2.c adc.c key.c ws2812.c
    ../User/inc/: uart2.h
  group CMSIS
    ../Device/Source/: startup_mm32f0010_keil.s system_mm32f0010.c
  group HAL_LIB
    ../Device/HAL_Lib/Src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c hal_tim.c
